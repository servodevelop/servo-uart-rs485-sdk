# Keil uVision project UartServo.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: UartServo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\FWLIB\inc;..\SYSTEM\sys;..\SYSTEM\sys_tick;..\HARDWARE\led;..\HARDWARE\fashion_star_uart_servo_examples;..\HARDWARE\ring_buffer;..\HARDWARE\usart;..\HARDWARE\fashion_star_uart_servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/fashion_star_uart_servo_examples/: fashion_star_uart_servo_examples.c
    ../HARDWARE/ring_buffer/: ring_buffer.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/fashion_star_uart_servo/: fashion_star_uart_servo.c
  group SYSTEM
    ../SYSTEM/sys_tick/: sys_tick.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group README
    ../: readme.txt
