# Keil uVision project FashionStarUartServo.uvprojx, settings and files
target FashionStarUartServo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FashionStarUartServo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Libraries\FWlib\src;..\Libraries\FWlib\inc;..\Project;..\User;..\User\usart;..\User\ring_buffer;..\User\sys_tick;..\User\fashion_star_uart_servo;..\User\fashion_star_uart_servo_examples
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c
    ../User/usart/: usart.c
    ../User/ring_buffer/: ring_buffer.c
    ../User/sys_tick/: sys_tick.c
    ../User/fashion_star_uart_servo/: fashion_star_uart_servo.c
    ../User/fashion_star_uart_servo_examples/: fashion_star_uart_servo_examples.c
software components: CMSIS:CORE 5.1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
